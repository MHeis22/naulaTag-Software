## boards/MH/naulaTAG_v1/naulaTAG_v1_nrf54l15_cpuflpr_defconfig
```kconfig
CONFIG_USE_DT_CODE_PARTITION=y
CONFIG_XIP=n
CONFIG_RISCV_ALWAYS_SWITCH_THROUGH_ECALL=y
```
